* SPICE netlist generated by Yosys 0.9 (git sha1 1979e0b1, gcc 10.3.0-1ubuntu1~20.10 -fPIC -Os)

X0 count.0 1 IVX1_CV
X1 exposecycles.1 2 IVX1_CV
X2 exposecycles.2 3 IVX1_CV
X3 exposecycles.3 4 IVX1_CV
X4 count.4 5 IVX1_CV
X5 exposecycles.5 6 IVX1_CV
X6 expose_finished 7 IVX1_CV
X7 1 exposecycles.0 8 ORX1_CV
X8 4 count.3 9 NDX1_CV
X9 3 count.2 10 NDX1_CV
X10 9 10 11 NDX1_CV
X11 4 count.3 12 ORX1_CV
X12 exposecycles.3 count.3 13 ENX1_CV
X13 exposecycles.2 count.2 14 ENX1_CV
X14 13 14 15 ANX1_CV
X15 1 exposecycles.0 16 NDX1_CV
X16 2 count.1 17 ANX1_CV
X17 exposecycles.1 count.1 18 ENX1_CV
X18 16 18 19 ANX1_CV
X19 exposecycles.4 5 20 ORX1_CV
X20 6 count.5 21 NDX1_CV
X21 20 21 22 NDX1_CV
X22 exposecycles.4 5 23 NDX1_CV
X23 6 count.5 24 ORX1_CV
X24 23 24 25 NDX1_CV
X25 22 25 26 NRX1_CV
X26 15 19 27 NDX1_CV
X27 8 26 28 NDX1_CV
X28 27 28 29 ORX1_CV
X29 15 17 30 NDX1_CV
X30 11 12 31 NDX1_CV
X31 30 31 32 ANX1_CV
X32 22 24 33 NDX1_CV
X33 expose_enable 33 34 ANX1_CV
X34 27 32 35 NDX1_CV
X35 26 35 36 NDX1_CV
X36 34 36 37 ANX1_CV
X37 1 37 38 ENX1_CV
X38 29 38 39 NDX1_CV
X39 40 29 41 ORX1_CV
X40 39 41 42 ANX1_CV
X41 reset 42 43 NRX1_CV
X42 count.0 count.1 44 ANX1_CV
X43 count.0 count.1 45 EOX1_CV
X44 37 45 46 NDX1_CV
X45 47 37 48 ORX1_CV
X46 46 48 49 ANX1_CV
X47 reset 49 50 NRX1_CV
X48 count.2 44 51 ANX1_CV
X49 count.2 44 52 EOX1_CV
X50 37 52 53 NDX1_CV
X51 54 37 55 ORX1_CV
X52 53 55 56 ANX1_CV
X53 reset 56 57 NRX1_CV
X54 37 51 58 NDX1_CV
X55 59 58 60 NDX1_CV
X56 59 58 61 NRX1_CV
X57 reset 61 62 NRX1_CV
X58 60 62 63 ANX1_CV
X59 count.3 51 64 ANX1_CV
X60 count.4 64 65 ANX1_CV
X61 5 64 66 ENX1_CV
X62 37 66 67 NDX1_CV
X63 68 37 69 ORX1_CV
X64 67 69 70 ANX1_CV
X65 reset 70 71 NRX1_CV
X66 37 65 72 NDX1_CV
X67 73 72 74 NDX1_CV
X68 73 72 75 NRX1_CV
X69 reset 75 76 NRX1_CV
X70 74 76 77 ANX1_CV
X71 expose 37 78 ORX1_CV
X72 29 78 79 ANX1_CV
X73 reset 79 80 ORX1_CV
X74 7 37 81 ORX1_CV
X75 29 81 82 ANX1_CV
X76 reset 82 83 NRX1_CV
X77 83 clk AVSS AVSS expose_finished 84 DFSRQNX1_CV
X78 80 clk AVSS AVSS expose 85 DFSRQNX1_CV
X79 43 clk AVSS AVSS count.0 40 DFSRQNX1_CV
X80 50 clk AVSS AVSS count.1 47 DFSRQNX1_CV
X81 57 clk AVSS AVSS count.2 54 DFSRQNX1_CV
X82 63 clk AVSS AVSS count.3 59 DFSRQNX1_CV
X83 71 clk AVSS AVSS count.4 68 DFSRQNX1_CV
X84 77 clk AVSS AVSS count.5 73 DFSRQNX1_CV
V0 86 40 DC 0
V1 87 47 DC 0
V2 88 54 DC 0
V3 89 59 DC 0
V4 90 68 DC 0
V5 91 73 DC 0
V6 92 count.0 DC 0
V7 93 exposecycles.0 DC 0
V8 94 exposecycles.1 DC 0
V9 95 count.1 DC 0
V10 96 exposecycles.2 DC 0
V11 97 count.2 DC 0
V12 98 exposecycles.3 DC 0
V13 99 count.3 DC 0
V14 100 exposecycles.4 DC 0
V15 101 count.4 DC 0
V16 102 exposecycles.5 DC 0
V17 103 count.5 DC 0
V18 104 expose_enable DC 0
V19 105 40 DC 0
V20 106.0 43 DC 0
V21 107 47 DC 0
V22 106.1 50 DC 0
V23 108 54 DC 0
V24 106.2 57 DC 0
V25 109 59 DC 0
V26 106.3 63 DC 0
V27 110 68 DC 0
V28 106.4 71 DC 0
V29 111 73 DC 0
V30 106.5 77 DC 0
V31 112 expose DC 0
V32 113 80 DC 0
V33 114 expose_finished DC 0
V34 115 83 DC 0
V35 116 reset DC 0

************************
* end of SPICE netlist *
************************
