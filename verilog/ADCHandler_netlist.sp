* SPICE netlist generated by Yosys 0.9 (git sha1 1979e0b1, gcc 10.3.0-1ubuntu1~20.10 -fPIC -Os)

X0 clk 1 IVX1_CV
X1 reset 2 IVX1_CV
X2 digital_ramp.1 digital_ramp.0 3 ANX1_CV
X3 digital_ramp.3 digital_ramp.2 4 ANX1_CV
X4 3 4 5 ANX1_CV
X5 digital_ramp.4 5 6 ANX1_CV
X6 digital_ramp.5 6 7 ANX1_CV
X7 digital_ramp.6 7 8 ANX1_CV
X8 digital_ramp.7 8 9 NDX1_CV
X9 enable 9 10 ANX1_CV
X10 enable 9 11 NDX1_CV
X11 analog_ramp 11 12 NDX1_CV
X12 clk 10 13 NDX1_CV
X13 12 13 14 NDX1_CV
X14 2 9 15 ANX1_CV
X15 14 15 16 ANX1_CV
X16 digital_ramp.0 10 17 NDX1_CV
X17 digital_ramp.0 10 18 ORX1_CV
X18 2 18 19 ANX1_CV
X19 17 19 20 ANX1_CV
X20 digital_ramp.1 digital_ramp.0 21 ENX1_CV
X21 22 11 23 NDX1_CV
X22 10 21 24 NDX1_CV
X23 23 24 25 NDX1_CV
X24 reset 25 26 NRX1_CV
X25 3 10 27 NDX1_CV
X26 28 27 29 ORX1_CV
X27 28 27 30 NDX1_CV
X28 2 30 31 ANX1_CV
X29 29 31 32 ANX1_CV
X30 33 29 34 EOX1_CV
X31 2 34 35 ANX1_CV
X32 digital_ramp.4 5 36 ENX1_CV
X33 10 36 37 NDX1_CV
X34 38 11 39 NDX1_CV
X35 2 37 40 ANX1_CV
X36 39 40 41 ANX1_CV
X37 digital_ramp.4 10 42 NDX1_CV
X38 6 10 43 NDX1_CV
X39 44 43 45 NDX1_CV
X40 44 43 46 ORX1_CV
X41 2 46 47 ANX1_CV
X42 45 47 48 ANX1_CV
X43 49 10 50 ORX1_CV
X44 digital_ramp.6 7 51 EOX1_CV
X45 enable 51 52 NDX1_CV
X46 50 52 53 NDX1_CV
X47 2 53 54 ANX1_CV
X48 digital_ramp.7 11 55 ORX1_CV
X49 8 10 56 NDX1_CV
X50 57 56 58 NDX1_CV
X51 57 56 59 ORX1_CV
X52 2 58 60 ANX1_CV
X53 59 60 61 ANX1_CV
X54 out.0 11 62 NDX1_CV
X55 17 62 63 NDX1_CV
X56 out.1 11 64 NDX1_CV
X57 digital_ramp.1 10 65 NDX1_CV
X58 64 65 66 NDX1_CV
X59 out.2 11 67 NDX1_CV
X60 digital_ramp.2 10 68 NDX1_CV
X61 67 68 69 NDX1_CV
X62 out.3 11 70 NDX1_CV
X63 digital_ramp.3 10 71 NDX1_CV
X64 70 71 72 NDX1_CV
X65 out.4 11 73 NDX1_CV
X66 42 73 74 NDX1_CV
X67 out.5 11 75 NDX1_CV
X68 digital_ramp.5 10 76 NDX1_CV
X69 75 76 77 NDX1_CV
X70 out.6 10 78 ORX1_CV
X71 digital_ramp.6 11 79 ORX1_CV
X72 78 79 80 ANX1_CV
X73 out.7 10 81 ORX1_CV
X74 55 81 82 ANX1_CV
X75 14 1 AVSS AVSS analog_ramp 83 DFSRQNX1_CV
X76 63 clk AVSS AVSS out.0 84 DFSRQNX1_CV
X77 66 clk AVSS AVSS out.1 85 DFSRQNX1_CV
X78 69 clk AVSS AVSS out.2 86 DFSRQNX1_CV
X79 72 clk AVSS AVSS out.3 87 DFSRQNX1_CV
X80 74 clk AVSS AVSS out.4 88 DFSRQNX1_CV
X81 77 clk AVSS AVSS out.5 89 DFSRQNX1_CV
X82 80 clk AVSS AVSS out.6 90 DFSRQNX1_CV
X83 82 clk AVSS AVSS out.7 91 DFSRQNX1_CV
X84 20 clk AVSS AVSS digital_ramp.0 92 DFSRQNX1_CV
X85 26 clk AVSS AVSS digital_ramp.1 22 DFSRQNX1_CV
X86 32 clk AVSS AVSS digital_ramp.2 28 DFSRQNX1_CV
X87 35 clk AVSS AVSS digital_ramp.3 33 DFSRQNX1_CV
X88 41 clk AVSS AVSS digital_ramp.4 38 DFSRQNX1_CV
X89 48 clk AVSS AVSS digital_ramp.5 44 DFSRQNX1_CV
X90 54 clk AVSS AVSS digital_ramp.6 49 DFSRQNX1_CV
X91 61 clk AVSS AVSS digital_ramp.7 57 DFSRQNX1_CV
X92 16 clk AVSS AVSS analog_ramp 93 DFSRQNX1_CV
V0 ADC_finished AVSS DC 0
V1 94 22 DC 0
V2 95 28 DC 0
V3 96 33 DC 0
V4 97 38 DC 0
V5 98 44 DC 0
V6 99 49 DC 0
V7 100 57 DC 0
V8 101 digital_ramp.5 DC 0
V9 102 digital_ramp.4 DC 0
V10 103 digital_ramp.3 DC 0
V11 104 digital_ramp.2 DC 0
V12 105 digital_ramp.1 DC 0
V13 106 digital_ramp.0 DC 0
V14 107 enable DC 0
V15 108 clk DC 0
V16 109 analog_ramp DC 0
V17 110 14 DC 0
V18 111 reset DC 0
V19 112 16 DC 0
V20 113.0 20 DC 0
V21 114 22 DC 0
V22 113.1 26 DC 0
V23 115 28 DC 0
V24 113.2 32 DC 0
V25 116 33 DC 0
V26 113.3 35 DC 0
V27 117 38 DC 0
V28 113.4 41 DC 0
V29 118 44 DC 0
V30 113.5 48 DC 0
V31 119 digital_ramp.6 DC 0
V32 120 49 DC 0
V33 113.6 54 DC 0
V34 121 digital_ramp.7 DC 0
V35 122 57 DC 0
V36 113.7 61 DC 0
V37 123 out.0 DC 0
V38 124.0 63 DC 0
V39 125 out.1 DC 0
V40 124.1 66 DC 0
V41 126 out.2 DC 0
V42 124.2 69 DC 0
V43 127 out.3 DC 0
V44 124.3 72 DC 0
V45 128 out.4 DC 0
V46 124.4 74 DC 0
V47 129 out.5 DC 0
V48 124.5 77 DC 0
V49 130 out.6 DC 0
V50 124.6 80 DC 0
V51 131 out.7 DC 0
V52 124.7 82 DC 0
V53 132 1 DC 0

************************
* end of SPICE netlist *
************************
